# Keil uVision project stc.uvproj, settings and files
target STC89C52 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: stc +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\src\beep;.\src\sys;.\src\led;.\src\relay;.\src\key;.\src\digital_pile;.\src;.\src\interrupt;.\src\lcd;.\src\ad;.\src\serial_port;.\src\motor
  group 启动
    ./: STARTUP.A51
    ./src/: main.c reg52.h
  group led
    ./src/led/: led1.c led1.h led2.c led2.h led3.c led3.h
  group beep
    ./src/beep/: beep1.c beep1.h beep2.c beep2.h beep3.c beep3.h
  group relay
    ./src/relay/: relay.c relay.h
  group sys
    ./src/sys/: sys.c sys.h
  group key
    ./src/key/: key.c key.h key2.c key2.h
  group digital_pile
    ./src/digital_pile/: digital_pile.c digital_pile.h
  group lcd
    ./src/lcd/: lcd1602.h lcd1602.c
  group ad
    ./src/ad/: adc0809.c adc0809.h
  group serial_port
    ./src/serial_port/: serial_prot.c serial_prot.h
  group motor
    ./src/motor/: step_motor.c
