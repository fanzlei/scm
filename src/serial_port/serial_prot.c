#include "serial_prot.h"
#include <reg52.h>
sbit K1 = P1^4;

void serial_port_send(){
	unsigned char i = 0;
unsigned int j;
	//?????,????1??????
  TMOD=0x20;//???1???????2,,8?????????
  TH1=0XF4;
  TL1=0xF4;//???4800
  ET1=1;
  TR1=1;

  //????????
  SCON=0x50; //??1,????
  PCON=0x00;
  TI= 0;
  RI= 0;
  ES=1;
  EA=1;
	K1 = 1;
	
	while(1){
		if(K1 == 0){
			i++;
			if(i > 9) i = 0;
			SBUF = i;
		}
		for(j=0;j<100;j++);
	}

}